Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T16:16:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 16:16:50 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\bfbfe087-5e50-4dc0-b2e7-e7b9e19ce169\ifc * Database version: 5507 * Database creation date: Mon Oct 24 16:16:50 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 16:16:50 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 16:16:50 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: 2CKA001012A1606, E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1606_NL-NL:2CKA001012A1606:4753072
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 150-150-150
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 10 mm; Height: 71 mm; Rounding Radius: 4 mm; Width: 71 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM
Type - Identity Data - Article Code: Default; Article Description: Schak serie inb zonder klauwen; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: yes; Description: Schak serie inb zonder klauwen; EMCS Version: 4.0; ETIM Article Class: EC001590; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395541104; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001012A1606; Manufacturer Type: 2000/5 USR-503; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395541104&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Revit Version: 2020; Type Name: 2CKA001012A1606; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1606_NL-NL
Type - Pset_EnvironmentalImpactIndicators - Reference: 2CKA001012A1606
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 2CKA001012A1606
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00701291 m2; Volume: 0.0000522726 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 3; VERSION: 220800
Other - Family: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1606_NL-NL: 2CKA001012A1606; Family and Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1606_NL-NL: 2CKA001012A1606; Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1606_NL-NL: 2CKA001012A1606; Type Id: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1606_NL-NL: 2CKA001012A1606
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: future linear_2CKA001754A4236_ver_2, E_Frame Vertical_Switch Series_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_NL-NL:future linear_2CKA001754A4236_ver_2:4753066
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 7 mm; Gang Height: 64 mm; Gang Width: 64 mm; Height: 151 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 0 mm; Width: 80 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Studiowit; Material: Color RAL 9016; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Afdekraam hoekig 2v f-studiowit; Article Type: 2-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Afdekraam hoekig 2v f-studiowit; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395050767; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001754A4236; Manufacturer Type: 1722-184K; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395050767&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 2-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: future linear; Revit Version: 2020; Type Name: future linear_2CKA001754A4236_ver_2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame Vertical_Switch Series_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_NL-NL
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_2CKA001754A4236_ver_2
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: future linear_2CKA001754A4236_ver_2
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0179918 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000437775 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-200 VA
Electrical - Loads - Load Classification: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Annotation Offset Position: 7 mm; Family: E_Frame Vertical_Switch Series_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_NL-NL: future linear_2CKA001754A4236_ver_2; Family and Type: E_Frame Vertical_Switch Series_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_NL-NL: future linear_2CKA001754A4236_ver_2; Gang 3: 71 mm; Gang Reference Line: 135 mm; Interior Width: 32 mm; Number of Representation Line: 2; Type: E_Frame Vertical_Switch Series_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_NL-NL: future linear_2CKA001754A4236_ver_2; Type Id: E_Frame Vertical_Switch Series_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_NL-NL: future linear_2CKA001754A4236_ver_2
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: future linear_with Earth 1F_2CKA002011A3780, E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3780_NL-NL:future linear_with Earth 1F_2CKA002011A3780:4753070
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9016
Type - Constraints - Default Elevation: 2800 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 63 mm; Rounding Radius: 1 mm; Width: 63 mm
Type - Electrical - Material: Color RAL 9016; App ID: EL_MODELPARTSYSTEM; Insert Type: Studiowit
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Wcd ra cpl inb s-studiowit; Article Type: Wandcontactdoos + RA inbouw 1V; Base Family Version: 20221003; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Description: Wcd ra cpl inb s-studiowit; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395031513; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002011A3780; Manufacturer Type: 20 EUCR-84-503; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395031513&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: Wandcontactdoos + RA inbouw 1V; OmniClass Number: 23.80.50.00; OmniClass Title: Terminals for Power Supply; Product Line: future linear; Revit Version: 2020; Type Name: future linear_with Earth 1F_2CKA002011A3780; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3780_NL-NL
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_with Earth 1F_2CKA002011A3780
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: future linear_with Earth 1F_2CKA002011A3780
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 19; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00753861 m2; Volume: 0.0000387512 m3
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 6; VERSION: 220800
Other - Annotation SocketOneFoldWithEarth: yes; Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3780_NL-NL: future linear_with Earth 1F_2CKA002011A3780; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3780_NL-NL: future linear_with Earth 1F_2CKA002011A3780; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3780_NL-NL: future linear_with Earth 1F_2CKA002011A3780; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA002011A3780_NL-NL: future linear_with Earth 1F_2CKA002011A3780
Phasing - Phase Created: 4. Plan over 10 years

# IfcSwitchingDevice: future linear_1 Pole_2CKA001751A2752, E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_NL-NL:future linear_1 Pole_2CKA001751A2752:4753071
In: F00
Type - PredefinedType: CONTACTOR; Material: Color RAL 9016
Type - Constraints - Default Elevation: 1050 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 63 mm; Rounding Radius: 1 mm; Width: 63 mm
Type - Electrical - Material: Color RAL 9016; App ID: EL_MODELPARTSYSTEM; Insert Type: Studiowit
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Wippen v serie wis/wis s-studiowit; Base Family Version: 20221003; Category: EL_DOUBLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Description: Wippen v serie wis/wis s-studiowit; EMCS Version: 4.0; ETIM Article Class: EC000011; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395995914; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001751A2752; Manufacturer Type: 1785-84; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395995914&LanguageCode=NL&Country=NL; MEPcontent Class: LIGHTING_DEVICES; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: future linear; Revit Version: 2020; Type Name: future linear_1 Pole_2CKA001751A2752; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Devices; Family Name: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_NL-NL
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_1 Pole_2CKA001751A2752
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_SwitchingDeviceTypeCommon - Reference: future linear_1 Pole_2CKA001751A2752
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0; Annotation: 3
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00997388 m2; Volume: 0.0000555402 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 1; VERSION: 220800
Other - Annotation SwitchSeriesOnePole: yes; Family: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_NL-NL: future linear_1 Pole_2CKA001751A2752; Family and Type: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_NL-NL: future linear_1 Pole_2CKA001751A2752; Type: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_NL-NL: future linear_1 Pole_2CKA001751A2752; Type Id: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_NL-NL: future linear_1 Pole_2CKA001751A2752
Phasing - Phase Created: 4. Plan over 10 years
